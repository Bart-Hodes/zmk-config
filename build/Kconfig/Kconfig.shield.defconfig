## build/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "/home/hodor/keyboard/zmk-config/zmk/app/boards/shields/*/Kconfig.defconfig"
```
